# Keil uVision project spi.uvprojx, settings and files
target spi (6120000::V6.12::.\ARMCLANG)
  device: STM32L552RCTx STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: managerbox +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L552xx
  c include: ../Core/Inc;    ../Drivers/STM32L5xx_HAL_Driver/Inc;    ../Drivers/STM32L5xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32L5xx/Include;    ../Drivers/CMSIS/Include;    ..\HARDWARE\BSP;    ..\HARDWARE\ES600;    ..\HARDWARE\IMU;    ..\HARDWARE\PROTOCAL;    ..\HARDWARE\QUEUE;    ..\HARDWARE\SPI_FLASH;    ..\HARDWARE\SPL06-007;    ..\HARDWARE\UART;    ..\MALLOC;    ..\cJSONFiles\cJSON
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: stm32l552xc_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32l552xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c iwdg.c spi.c tim.c usart.c stm32l5xx_it.c stm32l5xx_hal_msp.c
  group Drivers/STM32L5xx_HAL_Driver
    ../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_cortex.c stm32l5xx_hal_icache.c stm32l5xx_hal_iwdg.c stm32l5xx_hal_spi.c stm32l5xx_hal_spi_ex.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l5xx.c
  group HARDWARE
    ../HARDWARE/BSP/: bsp.c
    ../HARDWARE/ES600/: es600s.c
    ../HARDWARE/IMU/: LSM6DSO.c
    ../HARDWARE/PROTOCAL/: protocol.c
    ../HARDWARE/QUEUE/: queue.c
    ../HARDWARE/SPI_FLASH/: W25QXX.c
    ../HARDWARE/SPL06-007/: spl06.c
    ../HARDWARE/UART/: bsp_uart.c
  group cJSON
    ../cJSONFiles/cJSON/: cJSON.c
  group MALLOC
    ../MALLOC/: malloc.c
software components: CMSIS:CORE 4.3.0
